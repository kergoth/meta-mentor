# lirc needs python 3, not 2
inherit python3native
RDEPENDS_${PN}-python = "python3"
